# Keil uVision project project.uvproj, settings and files
target CMS8S6990SS24 (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code\CMS;.\Code\Lib;.\Code\User;.\Code\Hardware\UART
  group User
    ./Code/User/: main.c isr.c All_include.h
  group Lib
    ./Code/Lib/: uart.c acmp.c adc.c buzzer.c epwm.c extint.c flash.c gpio.c i2c.c lse.c opa.c pga.c spi.c system.c timer.c wdt.c
  group CMS
    ./Code/CMS/: cms8s6990.h startup_cms8s6990.A51
  group Hardware
    ./Code/Hardware/UART/: Test_Uart.c
    ./Code/Hardware/LED/: Test_LED.c Test_LED.h
    ./Code/Hardware/TIMER/: Test_timer.c Test_timer.h
    ./Code/Hardware/DELAY/: delay.c delay.h
    ./Code/Hardware/EPWM/: Breathing_lamp.c Breathing_lamp.h
    ./Code/Hardware/ADC/: Voltage_Sampling.c Voltage_Sampling.h
